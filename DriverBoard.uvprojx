# Keil uVision project DriverBoard.uvprojx, settings and files
target DriverBoard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: driverBoard
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output --bin --output ./bin/DRIVER.BIN ./Obj/driverBoard.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CM3;.\FWlib\inc;.\startup;.\user;.\driver;.\bsp;.\nvic
  memory RVCT4: ROM 0x8008000 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ./startup/: startup_stm32f10x_md.s
  group CM3
    ./CM3/: core_cm3.c system_stm32f10x.c
  group FWlib
    ./FWlib/SRC/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group NVIC
    ./nvic/: stm32f10x_it.c
  group DRIVER
    ./driver/: adc.c address.c led.c ctrl_output.c io_position.c moto.c rtc.c systick.c rcc.c uart1.c timer2.c timer3.c timer4.c
  group BSP
    ./bsp/: bsp_motor.c bsp_led.c bsp_output.c bsp_others.c bsp_master.c bsp_timer.c
  group USER
    ./user/: main.c motor_logic.c sys.c delay.c master_protocol.c
    ./bin/: version.txt
